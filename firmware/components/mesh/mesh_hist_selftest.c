// Known-answer tests of the journal's crypto primitives (#98): run by the host tests on the portable code and by the
// badge at boot on the hardware path (mesh_hist_crypto.h). Vectors: FIPS 180-2 (SHA-256 "abc"), RFC 4231 test cases
// 1, 2 and 6 (HMAC-SHA-256, case 6 with a key longer than a block), NIST SP 800-38A F.5.1 (AES-128-CTR, four blocks),
// and two of our own made with Python hashlib / cryptography: the parts-concatenation of mh_sha256 and a 100-byte CTR
// run from block 0 with our counter layout.
#include "mesh_hist_crypto.h"

#include <string.h>

static uint8_t const SHA_ABC[32] = {0xba, 0x78, 0x16, 0xbf, 0x8f, 0x01, 0xcf, 0xea, 0x41, 0x41, 0x40,
                                    0xde, 0x5d, 0xae, 0x22, 0x23, 0xb0, 0x03, 0x61, 0xa3, 0x96, 0x17,
                                    0x7a, 0x9c, 0xb4, 0x10, 0xff, 0x61, 0xf2, 0x00, 0x15, 0xad};
// SHA-256("lichen" | 00 01 .. 3f)
static uint8_t const SHA_PARTS[32] = {0x29, 0xed, 0xc4, 0x21, 0xa2, 0x62, 0xbc, 0x85, 0xf1, 0x9a, 0x5f,
                                      0x9a, 0x7f, 0xee, 0x91, 0x1a, 0xcb, 0x3b, 0xbc, 0xa1, 0xbe, 0x1f,
                                      0x9f, 0xbf, 0xf7, 0x2e, 0xf3, 0xbf, 0x11, 0x13, 0xa9, 0x7c};
static uint8_t const HMAC_TC1[32] = {0xb0, 0x34, 0x4c, 0x61, 0xd8, 0xdb, 0x38, 0x53, 0x5c, 0xa8, 0xaf,
                                     0xce, 0xaf, 0x0b, 0xf1, 0x2b, 0x88, 0x1d, 0xc2, 0x00, 0xc9, 0x83,
                                     0x3d, 0xa7, 0x26, 0xe9, 0x37, 0x6c, 0x2e, 0x32, 0xcf, 0xf7};
static uint8_t const HMAC_TC2[32] = {0x5b, 0xdc, 0xc1, 0x46, 0xbf, 0x60, 0x75, 0x4e, 0x6a, 0x04, 0x24,
                                     0x26, 0x08, 0x95, 0x75, 0xc7, 0x5a, 0x00, 0x3f, 0x08, 0x9d, 0x27,
                                     0x39, 0x83, 0x9d, 0xec, 0x58, 0xb9, 0x64, 0xec, 0x38, 0x43};
static uint8_t const HMAC_TC6[32] = {0x60, 0xe4, 0x31, 0x59, 0x1e, 0xe0, 0xb6, 0x7f, 0x0d, 0x8a, 0x26,
                                     0xaa, 0xcb, 0xf5, 0xb7, 0x7f, 0x8e, 0x0b, 0xc6, 0x21, 0x37, 0x28,
                                     0xc5, 0x14, 0x05, 0x46, 0x04, 0x0f, 0x0e, 0xe3, 0x7f, 0x54};
static uint8_t const NIST_KEY[16] = {0x2b, 0x7e, 0x15, 0x16, 0x28, 0xae, 0xd2, 0xa6,
                                     0xab, 0xf7, 0x15, 0x88, 0x09, 0xcf, 0x4f, 0x3c};
static uint8_t const NIST_PT[64]  = {
    0x6b, 0xc1, 0xbe, 0xe2, 0x2e, 0x40, 0x9f, 0x96, 0xe9, 0x3d, 0x7e, 0x11, 0x73, 0x93, 0x17, 0x2a,
    0xae, 0x2d, 0x8a, 0x57, 0x1e, 0x03, 0xac, 0x9c, 0x9e, 0xb7, 0x6f, 0xac, 0x45, 0xaf, 0x8e, 0x51,
    0x30, 0xc8, 0x1c, 0x46, 0xa3, 0x5c, 0xe4, 0x11, 0xe5, 0xfb, 0xc1, 0x19, 0x1a, 0x0a, 0x52, 0xef,
    0xf6, 0x9f, 0x24, 0x45, 0xdf, 0x4f, 0x9b, 0x17, 0xad, 0x2b, 0x41, 0x7b, 0xe6, 0x6c, 0x37, 0x10};
static uint8_t const NIST_CT[64] = {
    0x87, 0x4d, 0x61, 0x91, 0xb6, 0x20, 0xe3, 0x26, 0x1b, 0xef, 0x68, 0x64, 0x99, 0x0d, 0xb6, 0xce,
    0x98, 0x06, 0xf6, 0x6b, 0x79, 0x70, 0xfd, 0xff, 0x86, 0x17, 0x18, 0x7b, 0xb9, 0xff, 0xfd, 0xff,
    0x5a, 0xe4, 0xdf, 0x3e, 0xdb, 0xd5, 0xd3, 0x5e, 0x5b, 0x4f, 0x09, 0x02, 0x0d, 0xb0, 0x3e, 0xab,
    0x1e, 0x03, 0x1d, 0xda, 0x2f, 0xbe, 0x03, 0xd1, 0x79, 0x21, 0x70, 0xa0, 0xf3, 0x00, 0x9c, 0xee};
// key 00..0f, iv a0..ab, plaintext 00..63, from block 0
static uint8_t const OWN_CT[100] = {
    0x07, 0x7d, 0x63, 0x40, 0xcf, 0x27, 0x1d, 0xc4, 0x5d, 0xf6, 0x29, 0xde, 0xf5, 0x89, 0xaf, 0x61, 0xec, 0xff, 0x7b,
    0x0e, 0x36, 0xd2, 0x6f, 0xa4, 0xb9, 0xbf, 0xc2, 0xb9, 0x6b, 0x4d, 0x6e, 0x7a, 0x8a, 0xa7, 0x1a, 0x98, 0x5a, 0xac,
    0x15, 0x2d, 0xa2, 0x51, 0x9f, 0x2b, 0x6a, 0x3f, 0x9e, 0x4f, 0x63, 0xdf, 0x11, 0x3b, 0xb7, 0x22, 0x0b, 0x98, 0x1d,
    0x29, 0x4b, 0xa0, 0x7e, 0xb0, 0xb1, 0x97, 0xda, 0xe2, 0x07, 0x72, 0x4b, 0xaf, 0xaa, 0x2a, 0x37, 0x97, 0xa8, 0x8f,
    0xe3, 0x96, 0x47, 0x9f, 0xec, 0x05, 0x1e, 0x1a, 0x67, 0xd4, 0xc0, 0xba, 0xda, 0x6f, 0xd4, 0x91, 0xb9, 0x38, 0x5a,
    0x22, 0x91, 0x50, 0xd1, 0xb1};

int mh_selftest(void) {
    uint8_t out[32], buf[131];
    if (!mh_sha256(out, "a", 1, "bc", 2) || memcmp(out, SHA_ABC, 32) != 0) {
        return 1;
    }
    for (size_t i = 0; i < 64; i++) {
        buf[i] = (uint8_t)i;
    }
    if (!mh_sha256(out, "lichen", 6, buf, 64) || memcmp(out, SHA_PARTS, 32) != 0) {
        return 2;
    }
    memset(buf, 0x0b, 20);
    if (!mh_hmac(out, buf, 20, "Hi ", 3, "There", 5, NULL, 0) || memcmp(out, HMAC_TC1, 32) != 0) {
        return 3;
    }
    if (!mh_hmac(out, (uint8_t const *)"Jefe", 4, "what do ", 8, "ya want ", 8, "for nothing?", 12) ||
        memcmp(out, HMAC_TC2, 32) != 0) {
        return 4;
    }
    static char const tc6[] = "Test Using Larger Than Block-Size Key - Hash Key First";
    memset(buf, 0xaa, 131);
    if (!mh_hmac(out, buf, 131, tc6, sizeof(tc6) - 1, NULL, 0, NULL, 0) || memcmp(out, HMAC_TC6, 32) != 0) {
        return 5;
    }
    uint8_t const nist_iv[12] = {0xf0, 0xf1, 0xf2, 0xf3, 0xf4, 0xf5, 0xf6, 0xf7, 0xf8, 0xf9, 0xfa, 0xfb};
    uint8_t       data[100];
    memcpy(data, NIST_PT, 64);
    if (!mh_aes128_ctr_at(NIST_KEY, nist_iv, 0xfcfdfeffu, data, 64) || memcmp(data, NIST_CT, 64) != 0) {
        return 6;
    }
    uint8_t key[16], iv[12];
    for (size_t i = 0; i < 100; i++) {
        data[i] = (uint8_t)i;
    }
    for (size_t i = 0; i < 16; i++) {
        key[i] = (uint8_t)i;
    }
    for (size_t i = 0; i < 12; i++) {
        iv[i] = (uint8_t)(0xa0 + i);
    }
    if (!mh_aes128_ctr(key, iv, data, 100) || memcmp(data, OWN_CT, 100) != 0) {
        return 7;
    }
    if (!mh_aes128_ctr(key, iv, data, 100)) { // CTR twice is the identity
        return 8;
    }
    for (size_t i = 0; i < 100; i++) {
        if (data[i] != (uint8_t)i) {
            return 8;
        }
    }
    return 0;
}
